<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\InterruptDrivenInput.ewp</path>
    </project>
    <project>
        <path>C:\Users\axiom\Desktop\oo.ewp</path>
    </project>
    <batchBuild />
</workspace>
